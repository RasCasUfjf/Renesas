<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\IOPORT_HAL_MG_AP.ewp</path>
  </project>
  <batchBuild/>
</workspace>


